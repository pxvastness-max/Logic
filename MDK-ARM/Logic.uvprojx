# Keil uVision project Logic.uvprojx, settings and files
target Logic (6240000::V6.24::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Logic +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx,DATA_IN_D2_SRAM
  c include: ..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\Drivers\CMSIS\Include;..\User;..\Code\0_Config;..\Code\1_App;..\Code\2_Services;..\Code\3_Devices;..\Code\4_BSP;..\Code\5_Platform;..\Middleware\FatFs;..\Middleware\FreeRTOS\include;..\Middleware\FreeRTOS\portable\GCC\ARM_CM7\r0p1;..\Middleware\Lvgl\include;..\Middleware\Lvgl
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\Code\0_Config\STM32H743II.sct
  link misc: --scatter=..\Code\0_Config\STM32H743II.sct --diag_suppress=6314
  group Startup
    ./: startup_stm32h743xx.s
  group User
    ../User/: main.c stm32h7xx_it.c system_stm32h7xx.c
  group Code/0_Config
    ../Code/0_Config/: ffconf.h gui_config.h platform_config.h STM32H743II.sct FreeRTOSConfig.h lv_conf.h platform_dwt_config.h
    ../User/: stm32h7xx_hal_conf.h
  group Code/1_App
    ../Code/1_App/capture/: app_capture.c
    ../Code/1_App/gui/: app_file.c app_gui.c app_protocol.c
    ../Code/1_App/main/: app_init.c
  group Code/2_Services
    ../Code/2_Services/compression/: compression_service.c dtfh_codec.c
    ../Code/2_Services/diagnostics/: diagnostics_cpu_monitor.c display_diagnostics.c
    ../Code/2_Services/filesystem/: fatfs_diskio.c fatfs_port.c file_manager.c filesystem.c
    ../Code/2_Services/gui/channels/: gui_channels.c
    ../Code/2_Services/gui/gesture/: gui_wave_gesture.c
    ../Code/2_Services/gui/pages/: gui_device_page.c gui_file_page.c gui_icons.c gui_panel.c gui_protocol_page.c gui_system_page.c
    ../Code/2_Services/hardware/: hardware_service.c
    ../Code/2_Services/la/: la_query.c la_service.c la_storage.c la_transfer.c
    ../Code/2_Services/log/: log_service.c
    ../Code/2_Services/lvgl/: gui_language.c gui_service.c lvgl_display_port.c lvgl_input_port.c lvgl_tick_port.c
    ../Code/2_Services/lvgl/resource/: resource_font.c resource_font_data.inc
    ../Code/2_Services/protocol/: protocol_edges.c protocol_iic.c protocol_service.c protocol_spi.c protocol_uart.c
    ../Code/2_Services/touch/: touch_service.c
    ../Code/2_Services/waveform/: wave_capture_data.c wave_raster.c wave_service.c
  group Code/3_Devices
    ../Code/3_Devices/display/: lcd.c
    ../Code/3_Devices/sd/: sd_card.c
    ../Code/3_Devices/touch/: touch.c
    ../Code/3_Devices/w9825g6kh/: w9825g6kh.c
  group Code/4_BSP
    ../Code/4_BSP/display/: bsp_dma2d.c bsp_ltdc_lcd.c
    ../Code/4_BSP/dma/: bsp_dma.c
    ../Code/4_BSP/init/: bsp_init.c
    ../Code/4_BSP/la/: la_ic.c
    ../Code/4_BSP/memory/: bsp_fmc_sdram.c
    ../Code/4_BSP/sd/: bsp_sdmmc.c
    ../Code/4_BSP/serial/: uart.c
    ../Code/4_BSP/timer/: bsp_timer.c
    ../Code/4_BSP/touch/: bsp_i2c_touch.c
  group Code/5_Platform
    ../Code/5_Platform/clock/: platform_clock.c
    ../Code/5_Platform/init/: platform_init.c
    ../Code/5_Platform/memory/: platform_memory.c
    ../Code/5_Platform/rtos/: freertos_hooks.c platform_runtime.c rtos_heap.c
    ../Code/5_Platform/system/: platform_system.c
    ../Code/5_Platform/time/: platform_dwt.c platform_hal_tick.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_mdma.c
  group Middleware/FatFs
    ../Middleware/FatFs/: ff.c ffunicode.c
  group Middleware/FreeRTOS
    ../Middleware/FreeRTOS/: event_groups.c list.c queue.c tasks.c stream_buffer.c timers.c
    ../Middleware/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middleware/FreeRTOS/portable/GCC/ARM_CM7/r0p1/: port.c
  group Middleware/LVGL
    ../Middleware/Lvgl/src/: lv_init.c
    ../Middleware/Lvgl/src/core/: lv_group.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style_gen.c lv_obj_style.c lv_obj_tree.c lv_obj.c lv_observer.c lv_refr.c
    ../Middleware/Lvgl/src/display/: lv_display.c
    ../Middleware/Lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../Middleware/Lvgl/src/draw/: lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_utils.c lv_draw_vector.c lv_draw.c
    ../Middleware/Lvgl/src/draw/sw/blend/: lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend.c
    ../Middleware/Lvgl/src/draw/sw/: lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask_rect.c lv_draw_sw_mask.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c lv_draw_sw.c
    ../Middleware/Lvgl/src/font/: lv_font.c lv_font_montserrat_14.c
    ../Middleware/Lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../Middleware/Lvgl/src/fs/: lv_fs.c
    ../Middleware/Lvgl/src/image/: lv_image_decoder.c lv_bin_decoder.c
    ../Middleware/Lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
    ../Middleware/Lvgl/src/layouts/: lv_layout.c
    ../Middleware/Lvgl/src/logging/: lv_log.c
    ../Middleware/Lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../Middleware/Lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Middleware/Lvgl/src/misc/cache/: lv_cache_entry.c lv_cache.c
    ../Middleware/Lvgl/src/misc/: lv_anim_timeline.c lv_anim.c lv_area.c lv_array.c lv_async.c lv_bidi_common.c lv_bidi.c lv_circle_buf.c lv_color_op.c lv_color.c lv_event.c lv_grad.c lv_iter.c lv_ll.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_rb.c lv_style_gen.c lv_style.c lv_templ.c lv_text_ap.c lv_text.c lv_timer.c lv_tree.c lv_utils.c
    ../Middleware/Lvgl/src/osal/: lv_os.c lv_os_none.c lv_freertos.c
    ../Middleware/Lvgl/src/stdlib/: lv_mem.c
    ../Middleware/Lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Middleware/Lvgl/src/themes/: lv_theme.c
    ../Middleware/Lvgl/src/themes/default/: lv_theme_default.c
    ../Middleware/Lvgl/src/tick/: lv_tick.c
    ../Middleware/Lvgl/src/widgets/arc/: lv_arc.c
    ../Middleware/Lvgl/src/widgets/button/: lv_button.c
    ../Middleware/Lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Middleware/Lvgl/src/widgets/image/: lv_image.c
    ../Middleware/Lvgl/src/widgets/label/: lv_label.c
    ../Middleware/Lvgl/src/widgets/switch/: lv_switch.c
    ../Middleware/Lvgl/include/lvgl/: lvgl.h
    ../Middleware/Lvgl/: lv_version.h
software components: CMSIS:CORE 6.2.0
